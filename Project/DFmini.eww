<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\BlinkLed\Project\BlinkLed.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\DFmini.ewp</path>
    </project>
    <batchBuild />
</workspace>
